# Keil uVision project I2C_24LC64.uvprojx, settings and files
target I2C_24LC64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Mini58LDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: I2C_24LC64
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group User
    ../: main.c
    ../../../../Library/StdDriver/src/: retarget.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c sys.c gpio.c uart.c
software components: CMSIS:CORE 5.1.1
